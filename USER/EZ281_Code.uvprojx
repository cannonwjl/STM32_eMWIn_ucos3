# Keil uVision project EZ281_Code.uvprojx, settings and files
target EZ281_Code (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: EZ281_Code +hex
  c flags: Optim=3
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\FWLIB\STM32F10x_FWLib\inc;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\IIC;..\HARDWARE\24CXX;..\HARDWARE\SPI;..\HARDWARE\FLASH;..\HARDWARE\TOUCH;..\HARDWARE\SRAM;..\HARDWARE\TIMER;..\MALLOC;..\USMART;..\TEXT;..\UCOSIII\uC-CPU;..\UCOSIII\uC-LIB;..\UCOSIII\UCOS_BSP;..\UCOSIII\uCOS_CONFIG;..\UCOSIII\uCOS-III\Source;..\UCOSIII\uC-LIB\Ports\ARM-Cortex-M3\RealView;..\UCOSIII\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;..\UCOSIII\uC-CPU\ARM-Cortex-M3\RealView;..\EMWIN\STemWin\Config;..\EMWIN\STemWin\inc;..\HARDWARE\STMFLASH;..\USER;..\EMWIN_DEMO\biaopan;..\EMWIN_DEMO\bmp;..\EMWIN_DEMO\numdisplay;..\EMWIN_DEMO\bmp;..\EMWIN_DEMO\erweima;..\HARDWARE\SHT3X;..\HARDWARE\SHT3X;..\HARDWARE\SPI;..\EMWIN_DEMO\Clock_Dial;..\PERIPHERAL;..\PERIPHERAL\SX1278\radio;..\PERIPHERAL\SX1278\platform\sx12xxEiger;..\HARDWARE\DS1302;..\HARDWARE\RTC;..\EMWIN_DEMO\textdisplay;..\EMWIN_DEMO\2D_DISPLAY
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c Platform_Configure.h reader.txt
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCD/: ILI93xx.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/SHT3X/: sht3x.c system.c
    ../HARDWARE/IIC/: i2c_hal.c myiic.c
    ../HARDWARE/DS1302/: DS1302.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/SRAM/: sram.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group MALLOC
    ../MALLOC/: malloc.c
  group FWLIB
    ../FWLIB/STM32F10x_FWLib/src/: misc.c stm32f10x_crc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_sdio.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_i2c.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_rtc.c
  group UCOSIII_BSP
    ../UCOSIII/UCOS_BSP/: bsp.c
  group UCOSIII_LIB
    ../UCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../UCOSIII/uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group UCOSIII_CORE
    ../UCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group UCOSIII_PORT
    ../UCOSIII/uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu_c.c os_cpu.h os_cpu_a.s
  group UCOSIII_CONFIG
    ../UCOSIII/uCOS_CONFIG/: app_cfg.h cpu_cfg.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h includes.h
  group EMWIN_Config
    ../EMWIN/STemWin/Config/: GUIConf.c LCDConf_FlexColor_Template.c GUI_X_Touch_Analog.c
    ../EMWIN/STemWin/OS/: GUI_X_UCOSIII.c
  group EMWIN_LIB
    ../EMWIN/STemWin/Lib/: STemWin526_CM3_OS_Keil.lib
  group UCOSIII_CPU
    ../UCOSIII/uC-CPU/: cpu_core.c
    ../UCOSIII/uC-CPU/ARM-Cortex-M3/RealView/: cpu_c.c cpu_a.asm
  group Emwin_Demo
    ../EMWIN_DEMO/2D_DISPLAY/: 2ddisplay.c
  group IMAGE
    ../EMWIN_DEMO/bmp/: Background_Image.c
  group PERIPHERAL
    ../PERIPHERAL/: api.c ggsensor.c VEML6070.c LowRFM.c veml6030.c EEPROM.C
    ../PERIPHERAL/SX1278/platform/sx12xxEiger/: spi_rf.c sx12xxEiger.c sx12xxUserfunc.c sx1276-Hal.c
    ../PERIPHERAL/SX1278/radio/: sx1276.c sx1276-LoRaMisc.c sx1276-LoRa.c
